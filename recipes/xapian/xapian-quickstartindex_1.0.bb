require xapian-quickstart.inc

DESCRIPTION += "This package provides the tool for creating the index."
PR = "r1"

SRC_URI[md5sum] = "757f72c82e68c2422286e6b6299a3652"
SRC_URI[sha256sum] = "58ccae4d28fb6434558764132d5c4e1d87a3134e4acb11eb11f92d2a748118f4"
