DESCRIPTION = "Gnome bug buddy"
LICENSE = "GPL"
SECTION = "x11/gnome"
DEPENDS = "gtk+ gconf libelf"

inherit gnome

SRC_URI[archive.md5sum] = "86a84389c206396eba680e93288d04c8"
SRC_URI[archive.sha256sum] = "ffdc70fe4a59c0aef42b5b0b72b08f17db2b1d9f49ba2b68722334ddbee5e3ca"

