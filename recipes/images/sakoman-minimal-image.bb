IMAGE_LINGUAS = ""

IMAGE_INSTALL = "base-files base-passwd dropbear netbase"

IMAGE_LOGIN_MANAGER = "busybox"

IMAGE_DEV_MANAGER = "busybox-mdev"

IMAGE_INIT_MANAGER = "sysvinit sysvinit-pidof"
IMAGE_INITSCRIPTS = ""

inherit image

